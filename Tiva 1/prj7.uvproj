# Keil uVision project prj7.uvproj, settings and files
target prj7 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: prj7
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: startup_TM4C123.s main.c ADC.c GPIO.c Potentiometer.c Temp_Sensor.c Timer.c UART.c sys-tic-timer.c motor_driver.c PWMController.c
  group include
    ./: tm4c123gh6pm.h ADC.h GPIO.h Potentiometer.h Temp_Sensor.h Timer.h typedefs.h UART.h motor_driver.h sys-tic-timer.h PWMController.h
